#
# Copyright (c) Siemens AG, 2023
#
# Authors:
#  Tobias Schaffner <tobias.schaffner@siemens.com>
#
# SPDX-License-Identifier: MIT

require rt-test-image-common.inc

# Realtime tooling
IMAGE_PREINSTALL += "jitterdebugger"
