#
# Copyright (c) Siemens AG, 2026
#
# Authors:
#  Tobias Schaffner <tobias.schaffner@siemens.com>
#
# SPDX-License-Identifier: MIT

# Pin the next branch to the revision the measured images were built from,
# instead of following its tip (SRCREV = AUTOREV in xenomai-images)
SRCREV = "db33f300adcfe70a3f15da02bb07342be611294f"
