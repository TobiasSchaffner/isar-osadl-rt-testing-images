#
# Copyright (c) Siemens AG, 2026
#
# Authors:
#  Tobias Schaffner <tobias.schaffner@siemens.com>
#
# SPDX-License-Identifier: MIT

# riscv64 support is not merged yet, build from the wip branch instead.
GIT_BRANCH = "wip/libevl-riscv"
